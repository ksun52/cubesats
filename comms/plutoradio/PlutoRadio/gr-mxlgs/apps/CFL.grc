<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>CFL</value></param>
<param><key>author</key><value>MXL</value></param>
<param><key>category</key><value>MXLGS</value></param>
<param><key>description</key><value>MXL Ground Station System - Default Frequency 437.485 MHz</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>mxlgs_gnuradio_3_7_13</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bit_oversampling</value></param>
<param><key>value</key><value>resamp_rate/bit_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gaussian_taps</value></param>
<param><key>value</key><value>firdes.gaussian(1, bit_oversampling, 1, 4*bit_oversampling)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>resamp_rate</value></param>
<param><key>value</key><value>samp_rate*I_interpolation/I_decimation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sqwave</value></param>
<param><key>value</key><value>(1,)*(resamp_rate/bit_rate)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>I_decimation</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>I_interpolation</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>TCP_host</value></param>
<param><key>value</key><value>"172.16.1.44"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>TCP_port</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"12600"</value></param>
</block>
<block>
<key>analog_frequency_modulator_fc</key>
<param><key>id</key><value>analog_frequency_modulator_fc_0</value></param>
<param><key>sensitivity</key><value>2*math.pi*txfmdev/(samp_rate)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bit_rate</value></param>
<param><key>value</key><value>9600</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-0.5</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>0.0.0.0</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>maxoutbuf</key><value>100</value></param>
<param><key>minoutbuf</key><value>100</value></param>
<param><key>port</key><value>12600</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0</value></param>
</block>
<block>
<key>demod_gfsk_g3ruh</key>
<param><key>id</key><value>demod_gfsk_g3ruh_0</value></param>
<param><key>baud_rate</key><value>9600</value></param>
<param><key>bit_avg</key><value>60</value></param>
<param><key>fsk_deviation</key><value>3000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>samp_per_sym</key><value>5</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0</value></param>
<param><key>affinity</key><value>1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>taps</key><value>firdes.low_pass(10, samp_rate, bit_rate*1.2, 6000, firdes.WIN_HANN)</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>from gnuradio import filter</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>from numpy import array, convolve</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from datetime import datetime</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>intFreq</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>resamp_rate/bit_rate</value></param>
<param><key>taps</key><value>convolve(array(gaussian_taps),array(sqwave))</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>mxlgs_ax25_packetization</key>
<param><key>id</key><value>mxlgs_ax25_packetization_0</value></param>
<param><key>bit_oversampling</key><value>bit_oversampling</value></param>
<param><key>decim</key><value>I_interpolation</value></param>
<param><key>end_tx_delay</key><value>5</value></param>
<param><key>interp</key><value>I_decimation</value></param>
<param><key>start_tx_delay</key><value>tx_delay</value></param>
</block>
<block>
<key>mxlgs_doppler_correction_cc</key>
<param><key>id</key><value>mxlgs_doppler_correction_cc_0</value></param>
<param><key>dir</key><value>1</value></param>
<param><key>int_freq</key><value>int(intFreq)</value></param>
<param><key>port</key><value>12800</value></param>
<param><key>rxfreq</key><value>int(rxfreq)</value></param>
<param><key>sampling_freq</key><value>samp_rate</value></param>
</block>
<block>
<key>mxlgs_doppler_correction_cc</key>
<param><key>id</key><value>mxlgs_doppler_correction_cc_1</value></param>
<param><key>dir</key><value>-1</value></param>
<param><key>int_freq</key><value>-int(intFreq)</value></param>
<param><key>port</key><value>12900</value></param>
<param><key>rxfreq</key><value>int(txfreq)</value></param>
<param><key>sampling_freq</key><value>samp_rate</value></param>
</block>
<block>
<key>pluto_sink</key>
<param><key>id</key><value>plutoSDR_sink</value></param>
<param><key>attenuation</key><value>60</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>cyclic</key><value>False</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>filter</key><value></value></param>
<param><key>uri</key><value>ip:192.168.2.1</value></param>
<param><key>frequency</key><value>txfreq+int(intFreq)</value></param>
<param><key>bandwidth</key><value>samp_rate</value></param>
<param><key>samplerate</key><value>samp_rate</value></param>
</block>
<block>
<key>pluto_source</key>
<param><key>id</key><value>plutoSDR_source</value></param>
<param><key>bbdc</key><value>True</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>uri</key><value>ip:192.168.2.1</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>filter</key><value></value></param>
<param><key>gain</key><value>"manual"</value></param>
<param><key>frequency</key><value>rxfreq+int(intFreq)</value></param>
<param><key>manual_gain</key><value>64.0</value></param>
<param><key>quadrature</key><value>True</value></param>
<param><key>rfdc</key><value>True</value></param>
<param><key>bandwidth</key><value>samp_rate</value></param>
<param><key>samplerate</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>I_interpolation</value></param>
<param><key>interp</key><value>I_decimation</value></param>
<param><key>taps</key><value>filter.design_filter(I_decimation, I_interpolation,0.4)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rxdevice_addr</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"serial=31C03D7"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rxfreq</value></param>
<param><key>value</key><value>437.3e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rxgain</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>640000</value></param>
</block>
<block>
<key>satellites_hdlc_deframer</key>
<param><key>id</key><value>satellites_hdlc_deframer_0</value></param>
<param><key>check_fcs</key><value>True</value></param>
<param><key>max_length</key><value>10000</value></param>
</block>
<block>
<key>satellites_pdu_to_kiss</key>
<param><key>id</key><value>satellites_pdu_to_kiss_0</value></param>
</block>
<block>
<key>satellites_print_timestamp</key>
<param><key>id</key><value>satellites_print_timestamp_0_0</value></param>
<param><key>fmt</key><value>%Y-%m-%d %H:%M:%S</value></param>
<param><key>count</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_delay</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>txdevice_addr</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"serial=31C03D7"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>txfmdev</value></param>
<param><key>value</key><value>6000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>txfreq</value></param>
<param><key>value</key><value>437.300e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>txgain</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>"TX/RX"</value></param>
<param><key>center_freq0</key><value>txfreq+int(intFreq)</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>txgain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>txdevice_addr</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value>"ax25_len"</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_1</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>rxfreq+int(intFreq)</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>True</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rxgain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>rxdevice_addr</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_frequency_modulator_fc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>mxlgs_doppler_correction_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>mxlgs_ax25_packetization_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>demod_gfsk_g3ruh_0</source_block_id><sink_block_id>satellites_hdlc_deframer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>demod_gfsk_g3ruh_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mxlgs_ax25_packetization_0</source_block_id><sink_block_id>blocks_uchar_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mxlgs_doppler_correction_cc_0</source_block_id><sink_block_id>fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mxlgs_doppler_correction_cc_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mxlgs_doppler_correction_cc_1</source_block_id><sink_block_id>plutoSDR_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mxlgs_doppler_correction_cc_1</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>plutoSDR_source</source_block_id><sink_block_id>mxlgs_doppler_correction_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>analog_frequency_modulator_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_hdlc_deframer_0</source_block_id><sink_block_id>satellites_print_timestamp_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_pdu_to_kiss_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>satellites_print_timestamp_0_0</source_block_id><sink_block_id>satellites_pdu_to_kiss_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_1</source_block_id><sink_block_id>mxlgs_doppler_correction_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
